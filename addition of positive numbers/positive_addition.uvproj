# Keil uVision project positive_addition.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: positive_addition
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  group Source Group 1
    ./: add_pos.s
